# Keil uVision project aux_stm32f030.uvprojx, settings and files
target aux_stm32f030 (6160000::V6.16::ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: aux_stm32f030 +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32F030x6,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0,NDEBUG
  c include: ../Inc;                      ../Drivers/STM32F0xx_HAL_Driver/Inc;                      ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                      ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Application/User
    ../Src/: user_main.cpp main.c stm32f0xx_it.c
    ../Inc/: user_main.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_dma.c stm32f0xx_ll_pwr.c stm32f0xx_ll_exti.c stm32f0xx_ll_tim.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c stm32f0xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
target debug (6160000::V6.16::ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: as above
  output: aux_stm32f030 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32F030x6,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0,DEBUG
  c include: ../Inc;                     ../Drivers/STM32F0xx_HAL_Driver/Inc;                     ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                     ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 5.5.0
