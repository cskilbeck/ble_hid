# Keil uVision project ble_hid_gamepad.uvprojx, settings and files
target DA14585 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_app_peripheral_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14585\Objects\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_585.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;..\..\DA14531_SDK_6.0.18.1182.1\sdk;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_ancc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_bass;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_bcss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_bmss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_bond_db;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_common;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_ctsc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_ctss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_custs;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_default_hnd;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_diss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_easy;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_entry;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_findme;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_gattc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_proxr;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_sec;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_suotar;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_udss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_wsss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\controller;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\controller\em;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\controller\llc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\controller\lld;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\controller\llm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\ea;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\ea\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\em;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\em\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\hci;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\hci\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\hci\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\att;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\att\attc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\att\attm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\att\atts;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gap;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gap\gapc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gap\gapm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gatt;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gatt\gattc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gatt\gattm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\l2c;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\l2c\l2cc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\l2c\l2cm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\smp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\smp\smpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\smp\smpm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anc\ancc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anc\ancc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anc\ancc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\basc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\basc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\basc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\bass;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\bass\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\bass\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcsc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcsc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcsc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmsc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmsc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmsc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cppc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cppc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cppc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cpps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cpps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cpps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctsc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctsc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctsc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\custom;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\custom\custs;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\custom\custs\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\custom\custs\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\disc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\disc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\disc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\diss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\diss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\diss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findl;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findl\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findl\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findt;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findt\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findt\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\gatt;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\gatt\gatt_client;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\gatt\gatt_client\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\gatt\gatt_client\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpbh;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpbh\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpbh\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpd;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpd\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpd\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogprh;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogprh\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogprh\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpt;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpt\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpt\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lanc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lanc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lanc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lans;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lans\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lans\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\paspc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\paspc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\paspc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\pasps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\pasps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\pasps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxm\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxm\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxr;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxr\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxr\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scppc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scppc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scppc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scpps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scpps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scpps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\suota;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\suota\suotar;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\suota\suotar\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\suota\suotar\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tipc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tipc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tipc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tips;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tips\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tips\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udsc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udsc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udsc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wssc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wssc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wssc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wsss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wsss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wsss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\rwble;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\rwble_hl;..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files;..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\IAR;..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\ldscripts;..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\misc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\scatterfiles;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\boot;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\boot\ARM;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\boot\ARM_clang;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\boot\GCC;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\boot\IAR;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\compiler;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\compiler\ARM;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\compiler\ARM_clang;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\compiler\GCC;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\compiler\IAR;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\ll;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\main;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\arch_console;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\common;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\common\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\crypto;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\dbg;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\dbg\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\gtl;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\gtl\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\gtl\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\h4tl;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\h4tl\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\ke;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\ke\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\ke\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\nvds;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\nvds\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\nvds\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rf;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rf\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rf\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rwip;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rwip\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rwip\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\adc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\battery;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\ble;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\dma;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\gpio;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\hw_otpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\i2c;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\i2c_eeprom;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\pdm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\reg;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\rtc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\spi;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\spi_flash;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\syscntl;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\systick;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\timer;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\trng;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\uart;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\wifi;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\wkupct_quadec;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.6.0;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.6.0\Include;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0\CMSIS;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\system_library;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\system_library\include;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\system_library\output;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\system_library\output\IAR;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\system_library\output\Keil_5;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\utilities;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\utilities\otp_cs;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\utilities\otp_hdr;..\..\DA14531_SDK_6.0.18.1182.1\third_party;..\..\DA14531_SDK_6.0.18.1182.1\third_party\crc32;..\..\DA14531_SDK_6.0.18.1182.1\third_party\hash;..\..\DA14531_SDK_6.0.18.1182.1\third_party\irng;..\..\DA14531_SDK_6.0.18.1182.1\third_party\micro_ecc;..\..\DA14531_SDK_6.0.18.1182.1\third_party\rand;
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_585.txt" ..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\misc\da14585_symbols.txt --symdefs=ble_app_peripheral_585_symdef.txt --any_placement=best_fit --datacompressor off
  group sdk_boot
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/core_modules/arch_console/: arch_console.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/core_modules/nvds/src/: nvds.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_hibernation.c arch_rom.c
    ../../DA14531_SDK_6.0.18.1182.1/third_party/rand/: chacha20.c
    ../../DA14531_SDK_6.0.18.1182.1/third_party/hash/: hash.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/system_library/output/Keil_5/: da14531.lib da14585_586.lib da14531_01_with_heap_logging.lib
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/utilities/otp_cs/: otp_cs.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/utilities/otp_hdr/: otp_hdr.c
  group sdk_driver
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/syscntl/: syscntl.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/gpio/: gpio.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/battery/: battery.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/adc/: adc_58x.c adc_531.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/spi/: spi_58x.c spi_531.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/spi_flash/: spi_flash.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/i2c/: i2c.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/uart/: uart.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/trng/: trng.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/driver/dma/: dma.c
  group sdk_ble
    ../../DA14531_SDK_6.0.18.1182.1/sdk/ble_stack/rwble/: rwble.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/core_modules/rwip/src/: rwip.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
  group sdk_profiles
    ../../DA14531_SDK_6.0.18.1182.1/sdk/ble_stack/host/att/attm/: attm_db_128.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/ble_stack/profiles/: prf_utils.c prf.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/ble_stack/profiles/custom/: custom_common.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c custs2.c custs2_task.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/ble_stack/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
  group sdk_app
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_entry/: app_entry_point.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c app_easy_whitelist.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    ../../DA14531_SDK_6.0.18.1182.1/sdk/app_modules/src/app_bond_db/: app_bond_db.c
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_config.h user_modules_config.h user_profiles_config.h user_callback_config.h
  group user_custom_profile
    ../src/custom_profile/: user_custs_config.c user_custs1_def.c user_custs2_def.c
  group user_app
    ../src/platform/: user_periph_setup.c
    ../src/: user_peripheral.c app_hogpd.c app_hogpd_task.c
  group headers
    ../src/: app_hogpd.h app_hogpd_defs.h app_hogpd_task.h user_peripheral.h
    ../src/custom_profile/: user_custs_config.h user_custs2_def.h user_custs1_def.h
    ../src/config/: user_periph_setup.h
target DA14586 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: ble_app_peripheral_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14586\Objects\@L.bin"  "!L"
  c flags: Optim=4 wLevel=2
  c define: __DA14586__
  c misc: --c99 --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_586.txt"
  c include: as above
  library: MicroLIB
  scatter file: .\..\src\config\copied_scatter_585_586.sct
  link misc: --feedback=".\unused_586.txt" ..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\misc\da14585_symbols.txt --symdefs=ble_app_peripheral_586_symdef.txt --any_placement=best_fit --datacompressor off
target DA14531 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: ble_app_peripheral_531 +hex
  AfterMake: fromelf --bincombined --output=".\out_DA14531\Objects\@L.bin"  "!L"
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: __DA14531__, CFG_BLE,CFG_PERIPHERAL,BLE_PERIPHERAL,CFG_PRF_CUST2,CFG_PRF_CUST1,CFG_APP,BLE_HID_DEVICE,CFG_PRF_HOGPD,CFG_APP_SECURITY,BLE_CUSTOM1_SERVER,BLE_CUSTOM2_SERVER
  c misc: --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude user_config.h --bss_threshold=0 --feedback=".\unused_531.txt"
  c include: ..\src;..\src\config;..\src\custom_profile;..\src\platform;..\..\DA14531_SDK_6.0.18.1182.1\sdk;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_ancc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_bass;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_bcss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_bmss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_bond_db;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_common;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_ctsc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_ctss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_custs;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_default_hnd;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_diss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_easy;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_entry;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_findme;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_gattc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_proxr;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_sec;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_suotar;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_udss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\app_modules\src\app_wsss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\controller;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\controller\em;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\controller\llc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\controller\lld;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\controller\llm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\ea;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\ea\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\em;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\em\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\hci;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\hci\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\hci\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\att;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\att\attc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\att\attm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\att\atts;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gap;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gap\gapc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gap\gapm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gatt;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gatt\gattc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\gatt\gattm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\l2c;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\l2c\l2cc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\l2c\l2cm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\smp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\smp\smpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\host\smp\smpm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anc\ancc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anc\ancc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anc\ancc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\anp\anps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\basc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\basc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\basc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\bass;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\bass\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bas\bass\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcsc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcsc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcsc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bcs\bcss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\blp\blps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmsc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmsc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmsc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\bms\bmss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cppc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cppc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cppc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cpps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cpps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cpp\cpps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cscp\cscps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctsc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctsc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctsc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\cts\ctss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\custom;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\custom\custs;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\custom\custs\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\custom\custs\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\disc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\disc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\disc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\diss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\diss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\dis\diss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findl;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findl\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findl\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findt;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findt\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\find\findt\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\gatt;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\gatt\gatt_client;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\gatt\gatt_client\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\gatt\gatt_client\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\glp\glps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpbh;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpbh\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpbh\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpd;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpd\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogpd\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogprh;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogprh\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hogp\hogprh\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\hrp\hrps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpt;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpt\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\htp\htpt\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lanc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lanc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lanc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lans;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lans\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\lan\lans\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\paspc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\paspc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\paspc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\pasps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\pasps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\pasp\pasps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxm\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxm\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxr;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxr\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\prox\proxr\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscpc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscpc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\rscp\rscps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scppc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scppc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scppc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scpps;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scpps\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\scpp\scpps\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\suota;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\suota\suotar;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\suota\suotar\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\suota\suotar\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tipc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tipc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tipc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tips;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tips\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\tip\tips\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udsc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udsc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udsc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\uds\udss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wssc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wssc\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wssc\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wsss;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wsss\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\profiles\wss\wsss\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\rwble;..\..\DA14531_SDK_6.0.18.1182.1\sdk\ble_stack\rwble_hl;..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files;..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\IAR;..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\ldscripts;..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\misc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\scatterfiles;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\boot;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\boot\ARM;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\boot\ARM_clang;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\boot\GCC;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\boot\IAR;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\compiler;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\compiler\ARM;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\compiler\ARM_clang;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\compiler\GCC;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\compiler\IAR;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\ll;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\arch\main;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\arch_console;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\common;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\common\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\crypto;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\dbg;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\dbg\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\gtl;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\gtl\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\gtl\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\h4tl;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\h4tl\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\ke;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\ke\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\ke\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\nvds;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\nvds\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\nvds\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rf;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rf\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rf\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rwip;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rwip\api;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\core_modules\rwip\src;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\adc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\battery;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\ble;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\dma;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\gpio;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\hw_otpc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\i2c;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\i2c_eeprom;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\pdm;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\reg;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\rtc;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\spi;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\spi_flash;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\syscntl;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\systick;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\timer;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\trng;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\uart;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\wifi;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\driver\wkupct_quadec;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.6.0;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.6.0\Include;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0\CMSIS;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\include\CMSIS\5.9.0\CMSIS\Core\Include;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\system_library;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\system_library\include;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\system_library\output;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\system_library\output\IAR;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\system_library\output\Keil_5;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\utilities;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\utilities\otp_cs;..\..\DA14531_SDK_6.0.18.1182.1\sdk\platform\utilities\otp_hdr;..\..\DA14531_SDK_6.0.18.1182.1\third_party;..\..\DA14531_SDK_6.0.18.1182.1\third_party\crc32;..\..\DA14531_SDK_6.0.18.1182.1\third_party\hash;..\..\DA14531_SDK_6.0.18.1182.1\third_party\irng;..\..\DA14531_SDK_6.0.18.1182.1\third_party\micro_ecc;..\..\DA14531_SDK_6.0.18.1182.1\third_party\rand
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\..\src\config\copied_scatter_531.sct
  link misc: --feedback=".\unused_531.txt" ..\..\DA14531_SDK_6.0.18.1182.1\sdk\common_project_files\misc\da14531_symbols.txt --symdefs=ble_app_peripheral_531_symdef.txt --any_placement=best_fit --datacompressor off
